## boards/shields/firebreak/Kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config SHIELD_FIREBREAK
    def_bool $(shields_list_contains,firebreak)
```
